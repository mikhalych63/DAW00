File: daw00/daw00.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Чтоб не потерялось
Other:
- added sheet Computer (computer.kicad_sch)
- added sheet Power (power.kicad_sch)
